# Repository Maddimax/MadControl

File README.md:

This contains all the files necessary to build your own Remote control ( or rather will soon )

# Hardware

The schematics and pcb files were created with [KiCad](http://www.kicad-pcb.org/display/KICAD/KiCad+EDA+Software+Suite)

# Software

All code was written with the standard Arduino IDE

# BOM 

Contains a list of all the components necessary

## KiCad design Hardware/DigitalBoard/DigitalBoard.kicad_pcb

Parts:
P1: IN-PORT0
P2: IN-PORT1
P3: CONN_5
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 10k
U1: TCA9535

Connections:
+5V: P1.1, P1.3, P1.5, P1.7, P1.9, P1.11, P1.13, P1.15, P2.1, P2.3, P2.5, P2.7, P2.9, P2.11, P2.13, P2.15, P3.1, U1.24 (Vcc)
DIGI_INT: P3.5, U1.1 (INT)
GND: P3.4, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, U1.12 (GND), U1.21 (A0)
unnamed: P2.6, R14.1, U1.15 (P12)
unnamed: P1.6, R3.2, U1.6 (P02)
unnamed: P1.4, R2.2, U1.5 (P01)
unnamed: P1.12, R6.2, U1.9 (P05)
unnamed: P2.4, R15.1, U1.14 (P11)
unnamed: P2.2, R16.1, U1.13 (P10)
unnamed: P2.16, R9.1, U1.20 (P17)
unnamed: P2.14, R10.1, U1.19 (P16)
unnamed: P2.12, R11.1, U1.18 (P15)
unnamed: P2.10, R12.1, U1.17 (P14)
unnamed: P2.8, R13.1, U1.16 (P13)
unnamed: P1.16, R8.2, U1.11 (P07)
unnamed: P1.14, R7.2, U1.10 (P06)
unnamed: P1.10, R5.2, U1.8 (P04)
unnamed: P1.8, R4.2, U1.7 (P03)
unnamed: P1.2, R1.2, U1.4 (P00)
SCL: P3.3, U1.22 (SCL)
SDA: P3.2, U1.23 (SDA)

Board: 2 copper layers, 24 parts (1 on the bottom side), 21 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design Hardware/RCShield-Mod/RCShield-Mod.kicad_pcb

Parts:
C1: 1000uF
C2: 220uF
D1: DIODE
K1: PPM_OUT
P1: ANALOG_EXT
P2: DIGI_EXT
P3: Vswitch
P7: Vinput
R1, R19: 10k
R2, R3: 1.5k
SHIELD1: ARDUINO_SHIELD
SHIELD2: ARDUINO_MEGA_SHIELD

Connections:
+5V: C2.1, P1.1, P2.1, R2.1, R3.1, SHIELD1.5V, SHIELD2.5V
ACCX: SHIELD1.AD0, SHIELD2.AD0
ACCY: SHIELD1.AD1, SHIELD2.AD1
ACCZ: SHIELD1.AD2, SHIELD2.AD2
DIGI_INT: P2.5, SHIELD2.AD15
DISPINT: SHIELD1.2, SHIELD2.2
GND: C1.2, C2.2, K1.1, P1.4, P2.4, P7.1, R19.1, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SHIELD2.GND1, SHIELD2.GND2, SHIELD2.GND3, SHIELD2.GND4, SHIELD2.GND5
GPUSEL: SHIELD1.8, SHIELD2.8
MISO: SHIELD1.12, SHIELD2.50 (PB3_(MISO))
MOSI: SHIELD1.11, SHIELD2.51 (PB2_(MOSI))
unnamed: D1.1 (A), P7.2 (PM)
PPM: K1.3, SHIELD2.13
SCK: SHIELD1.13, SHIELD2.52 (PB1_(SCK))
SCL: P1.3, P2.3, R3.2, SHIELD2.21 (SCL)
SDA: P1.2, P2.2, R2.2, SHIELD2.20 (SDA)
SDSEL: SHIELD1.9, SHIELD2.9
VIN: K1.2 (PM), P3.2 (PM), R1.2, SHIELD2.V_IN
Valways: C1.1, D1.2 (K), P3.1
Vsense: R1.1, R19.2, SHIELD2.AD3

Board: 2 copper layers, 14 parts (3 on the bottom side), 19 nets.

## KiCad design Hardware/AnalogBoard/AnalogBoard.kicad_pcb

Parts:
P1: CONN_4
P2: ACH67
P3: ACH45
P4: ACH23
P5: ACH01
U1, U4: 10uf
U2, U3: 0.1uf
U5: LTC2309
U6: 2.2uf

Connections:
+5V: P1.1, P2.1, P2.4, P3.1, P3.4, P4.1, P4.4, P5.1, P5.4, U1.1, U2.1, U5.3 (VDD), U5.10 (VDD)
GND: P1.4, P2.3, P2.6, P3.3, P3.6, P4.3, P4.6, P5.3, P5.6, U1.2, U2.2, U3.1, U4.2, U5.2 (GND), U5.4 (AD0), U5.5 (AD1), U5.8 (GND), U5.9 (GND), U5.19 (COM), U6.1
unnamed: P5.5, U5.11 (CH0)
unnamed: P4.2, U5.14 (CH3)
unnamed: P2.5, U5.17 (CH6)
unnamed: P3.2, U5.16 (CH5)
unnamed: P3.5, U5.15 (CH4)
unnamed: P4.5, U5.13 (CH2)
unnamed: P5.2, U5.12 (CH1)
unnamed: U5.20 (VREF), U6.2
unnamed: U3.2, U4.1, U5.1 (REFCOMP)
unnamed: P2.2, U5.18 (CH7)
SCL: P1.3, U5.6 (SCL)
SDA: P1.2, U5.7 (SDA)

Board: 2 copper layers, 15 parts (1 on the bottom side), 14 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin

## KiCad design Hardware/RCShield/RCShield.kicad_pcb

Parts:
0.1uf1, 0.1uf2, 2.2uf1, 10uf1, 10uf2: C
1,5k1: 1,5k
K1: PPM_OUT
P1: IN-PORT0
P2: IN-PORT1
P3: ACH67
P4: ACH45
P5: ACH23
P6: ACH01
P7: Vinput
R1, R2, R3, R4, R5, R6, R7, R8, R9, R11, R12, R13, R14, R15, R16, R17, R18, R19: 10k
R10: 1,5k
SHIELD1: ARDUINO_SHIELD
SHIELD2: ARDUINO_MEGA_SHIELD
U1: LTC2309
U2: TCA9535

Connections:
+5V: 0.1uf1.1, 1,5k1.2, 10uf1.1, P1.1, P1.3, P1.5, P1.7, P1.9, P1.11, P1.13, P1.15, P2.1, P2.3, P2.5, P2.7, P2.9, P2.11, P2.13, P2.15, P3.1, P3.4, P4.1, P4.4, P5.1, P5.4, P6.1, P6.4, R10.2, SHIELD1.5V, SHIELD2.5V, U1.3 (VDD), U1.10 (VDD), U2.24 (Vcc)
ACCX: SHIELD1.AD0, SHIELD2.AD0
ACCY: SHIELD1.AD1, SHIELD2.AD1
ACCZ: SHIELD1.AD2, SHIELD2.AD2
DIGI_INT: SHIELD2.AD15, U2.1 (INT)
DISPINT: SHIELD1.2, SHIELD2.2
GND: 0.1uf1.2, 0.1uf2.1, 2.2uf1.1, 10uf1.2, 10uf2.2, K1.1, P3.3, P3.6, P4.3, P4.6, P5.3, P5.6, P6.3, P6.6, P7.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.1, SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SHIELD2.GND1, SHIELD2.GND2, SHIELD2.GND3, SHIELD2.GND4, SHIELD2.GND5, U1.2 (GND), U1.4 (AD0), U1.5 (AD1), U1.8 (GND), U1.9 (GND), U1.19 (COM), U2.2 (A1), U2.3 (A2), U2.12 (GND), U2.21 (A0)
GPUSEL: SHIELD1.8, SHIELD2.8
MISO: SHIELD1.12, SHIELD2.50 (PB3_(MISO))
MOSI: SHIELD1.11, SHIELD2.51 (PB2_(MOSI))
unnamed: P3.2, U1.18 (CH7)
unnamed: P6.2, U1.12 (CH1)
unnamed: P6.5, U1.11 (CH0)
unnamed: P4.5, U1.15 (CH4)
unnamed: P3.5, U1.17 (CH6)
unnamed: P4.2, U1.16 (CH5)
unnamed: P5.2, U1.14 (CH3)
unnamed: P5.5, U1.13 (CH2)
unnamed: 0.1uf2.2, 10uf2.1, U1.1 (REFCOMP)
unnamed: 2.2uf1.2, U1.20 (VREF)
unnamed: P1.8, R5.2, U2.7 (P03)
unnamed: P2.4, R17.1, U2.14 (P11)
unnamed: P1.16, R9.2, U2.11 (P07)
unnamed: P1.14, R8.2, U2.10 (P06)
unnamed: P1.12, R7.2, U2.9 (P05)
unnamed: P1.10, R6.2, U2.8 (P04)
unnamed: P2.2, R18.1, U2.13 (P10)
unnamed: P1.2, R2.2, U2.4 (P00)
unnamed: P1.6, R4.2, U2.6 (P02)
unnamed: P1.4, R3.2, U2.5 (P01)
unnamed: P2.14, R12.1, U2.19 (P16)
unnamed: P2.16, R11.1, U2.20 (P17)
unnamed: P2.12, R13.1, U2.18 (P15)
unnamed: P2.10, R14.1, U2.17 (P14)
unnamed: P2.8, R15.1, U2.16 (P13)
unnamed: P2.6, R16.1, U2.15 (P12)
PPM: K1.3, SHIELD2.13
SCK: SHIELD1.13, SHIELD2.52 (PB1_(SCK))
SCL: 1,5k1.1, SHIELD2.21 (SCL), U1.6 (SCL), U2.22 (SCL)
SDA: R10.1, SHIELD2.20 (SDA), U1.7 (SDA), U2.23 (SDA)
SDSEL: SHIELD1.9, SHIELD2.9
VIN: K1.2, P7.2, R1.2, SHIELD2.V_IN
Vsense: R1.1, R19.2, SHIELD2.AD14

Board: 2 copper layers, 37 parts (0 on the bottom side), 43 nets.

## KiCad design Hardware/IOBreakout/IOBreakout.kicad_pcb

Parts:
P1, P2: CONN_10
P3, P4: CONN_12
U1: LTC2309
U2: TCA9535

Connections:
GND: P1.2, P1.3, P1.9, P3.1, U1.2 (GND), U1.8 (GND), U1.9 (GND), U2.12 (GND)
unnamed: P3.8, U2.5 (P01)
unnamed: P3.2, U2.11 (P07)
unnamed: P3.3, U2.10 (P06)
unnamed: P3.4, U2.9 (P05)
unnamed: P3.5, U2.8 (P04)
unnamed: P3.6, U2.7 (P03)
unnamed: P3.7, U2.6 (P02)
unnamed: P3.9, U2.4 (P00)
unnamed: P3.10, U2.3 (A2)
unnamed: P3.11, U2.2 (A1)
unnamed: P3.12, U2.1 (INT)
unnamed: P4.1, U2.24 (Vcc)
unnamed: P4.4, U2.21 (A0)
unnamed: P4.12, U2.13 (P10)
unnamed: P4.11, U2.14 (P11)
unnamed: P4.10, U2.15 (P12)
unnamed: P4.5, U2.20 (P17)
unnamed: P4.6, U2.19 (P16)
unnamed: P4.7, U2.18 (P15)
unnamed: P4.8, U2.17 (P14)
unnamed: P4.9, U2.16 (P13)
unnamed: P1.10, U1.1 (REFCOMP)
unnamed: P2.2, U1.19 (COM)
unnamed: P2.3, U1.18 (CH7)
unnamed: P1.1, U1.10 (VDD)
unnamed: P1.8, U1.3 (VDD)
unnamed: P1.7, U1.4 (AD0)
unnamed: P1.6, U1.5 (AD1)
unnamed: P1.5, P4.3, U1.6 (SCL), U2.22 (SCL)
unnamed: P1.4, P4.2, U1.7 (SDA), U2.23 (SDA)
unnamed: P2.1, U1.20 (VREF)
unnamed: P2.8, U1.13 (CH2)
unnamed: P2.7, U1.14 (CH3)
unnamed: P2.6, U1.15 (CH4)
unnamed: P2.5, U1.16 (CH5)
unnamed: P2.4, U1.17 (CH6)
unnamed: P2.9, U1.12 (CH1)
unnamed: P2.10, U1.11 (CH0)

Board: 2 copper layers, 6 parts (4 on the bottom side), 39 nets.

File BOM/BOM.md:

# Kits:

* Gameduino 2 		: (http://excamera.com/sphinx/gameduino2/)
* Arduino Mega 2560 : (http://arduino.cc/de/Main/ArduinoBoardMega2560)
* OrangeTx DIY      : [HK-OrangeTx-DIY-Module](http://www.hobbyking.com/hobbyking/store/__40205__OrangeRX_D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

# Components

* LTC2309           : [HBE-Shop-LTC2309](https://hbe-shop.de/Art-2294612-LINEAR-TECHNOLOGY-LTC2309CFP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
* TCA9535           : [HBE-Shop-TCA9535](https://hbe-shop.de/Art-2335659-TEXAS-INSTRUMENTS-TCA9535PWR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
* 2 Axis Gimbal     : [Robotshop-GIM01](http://www.robotshop.com/eu/en/axis-joystick-gim.html)
* 10nf              : Ceramic SMD
* 0.1nf             : Ceramic SMD
* 2.2nf             : Ceramic SMD
* 10kΩ				: SMD
* 1.5kΩ				: SMD
* S1G (Diode)		: SMD
* Pin header        : [Conrad-PinHeader](http://www.conrad.de/ce/de/product/741146/Stiftleiste-RM-254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
* Pin Header (f)    : [Conrad-PinHeader(f)](http://www.conrad.de/ce/de/product/740668/Einreihige-Buchsen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

# Enclosures
* Shapeways         : TBD
* Thingyverse       : TBD

## Commit log

2014-05-04 * Adding the IO Breakout board
2014-05-04 * Added initial BOM
2014-05-04 Renaming Software directory Updating README.md
2014-05-04 Adding python powerlut utility Renaming Channels to ADCChannels
2014-05-04 Implementing Input Channels Implementing ChannelMeter
2014-05-04 Fixing path case
2014-05-05 Changed "Unipolar" to "Bipolar" Created point curve filter with variable number of points Added Linear Filter ( Dual Rate )
2014-05-05 Added Palette Added Button widget Added XYWidget Updated Mainscreen Started Setup screen Improved ExpoFilter Performance Fixed LinearFilter amount Switched to 7 step PointCurve
2014-05-09 First iteration of the RC shield
2014-05-11 Connected I2C Components on the PCB
2014-05-11 Adding Vsense and PPM Generator Adding PCB File
2014-05-11 Changed cap footprints
2014-05-11 Creating Breakout boards for the IO's ( not in main shield yet )
2014-05-12 Adding modular mainboard
2014-05-12 Changing VIA Size for the Analog Board Moving Analog Board away from Digital board connector
2014-05-12 * Updating BOM
2014-05-17 Updated PCB to make it more DIY friendly Changed Vsense pin to A3 Added Design Folder
2014-05-19 Adding Filter Cap to main board Adding ADC Channel re-map Disabling digital IO Configuration in preparation for the new breakout board.
2014-06-12 * Updating PCB to more rectangular + Caps + On/Off Switch * Disabling Digital Breakout board for now
